Properties of the parts of a building model (IFC2X3)

# File
Description: Raumtemperaturregler UP, 230 VAC, Öffner, 3000W, alre-Rahmen, Abdeckung 50 x 50 mm, reinweiß, glänzend, ViewDefinition[CoordinationView]
File name: ifc-2x3.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: UA090016, Raumtemperaturregler UP, 230 VAC, Öffner, 3000W, alre-Rahmen, Abdeckung 50 x 50 mm, reinweiß, glänzend
In: Raum
Description: Elektromechanischer Unterputz-Raumtemperaturregler zur Regelung oder Überwachung von Temperaturen in Büros, Wohnräumen und Hotels. Besonders für Elektroheizungen mit großer Leistung geeignet. Durch die thermische Rückführung wird eine sehr genaue Schaltdifferenz erreicht (ab Heizleistung größer 1500 W Klemme N nicht anschließen). Mit der unter dem Einstellknopf befindlichen Bereichseinengung kann der Einstellbereich verändert werden. Einfacher elektrischer Anschluss ohne Schrauben. Neue Klemmen für eine einfache und schnelle Installation. Vereinfachte Verdrahtung durch Farbcodierung der Klemmen. Zeitersparnis durch Baukastenprinzip: Praktische Reihenfolge der Montage von Regler, Rahmen und Abdeckung. Geringes Einbauvolumen für eine komfortable und schnelle Montage in der Unterputzdose. Temperaturregelung bereits ohne Abdeckung möglich. Geschlossene Bauform. Optimale Schraubenaufnahme.; Classification: EC010927 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: UA090016; ModelLabel: RTBSU-401.086#21; GlobalTradeItemNumber: 4050528075741; ProductURL: https://alre.de/produkt_UA090016
Pset_Specification - NominalLength: 0.085 m; NominalWidth: 0.081 m; NominalDepth: 0.0418 m; NetWeight: 0.072
Pset_ALRE_ETIM_Properties - Montageart: Unterputz; Farbe: weiß; Breite: 81; Höhe: 85; Tiefe: 41.8; RAL-Nummer: 9010; Anschluss: 3-Draht; Art der Spannungsversorgung: 230 V AC; Kontaktausführung: Öffner (NC); Messbereich: 5; Bedienung: Dreh; Explosionsgeschützt: no; Schutzart (IP): IP30; Ausführung Aufnehmer/Fühler: Bimetall; Klasse des Temperaturreglers: I; Schutzart (NEMA): sonstige; Verdeckte Bedienung: no; Max. Spannung der Kontakte: 230; Mit Empfänger: no; Regelcharakteristik: P; Anzahl der Ausgänge Heizung: 1; Anzahl der Ausgänge Kühlung: 0; Temperatur ablesbar: no; Max. Kontaktbelastung: 13; Differenzwert: 0.5; Sensor extern: no; Thermische Rückkopplung: parallel; Differenz verstellbar: no; Geeignet für Heizung: yes; Geeignet für Kühlen: no; ETIM-Klasse: EC010927; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-UA090016.pdf
